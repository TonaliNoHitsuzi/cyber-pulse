# Keil uVision project STM32KeilPrj.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\App\Main;..\App\DataType;..\HW\RCC;..\HW\Timer;..\HW\UART1;..\FW\inc;..\ARM\NVIC;..\ARM\SysTick;..\ARM\System;..\App\LED;..\App\OLED;..\App\Experiments;..\App\HostIf;..\App\RunClock;..\HW\IWDG;..\HW\Flash;..\HW\PWM;..\HW\ADC;..\HW\DAC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
    ../App/OLED/: OLED.c
    ../App/Experiments/: exp_01.c exp_02.c exp_03.c exp_04.c exp_05.c exp_06.c exp_07.c exp_08.c exp_09.c exp_10.c exp_11.c exp_12.c exp_13.c exp_14.c exp_15.c exp_16.c exp_17.c nav.c experiments.c framework.c
    ../App/RunClock/: RunClock.c
    ../App/HostIf/: hostif.c
  group HW
    ../HW/RCC/: RCC.c
    ../HW/IWDG/: IWDG.c
    ../HW/Flash/: Flash.c
    ../HW/PWM/: PWM.c
    ../HW/ADC/: ADC.c U16Queue.c
    ../HW/DAC/: DAC.c Wave.c
    ../HW/UART1/: Queue.c UART1.c
  group FW
    ../FW/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_iwdg.c
  group ARM
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
    ../ARM/System/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
